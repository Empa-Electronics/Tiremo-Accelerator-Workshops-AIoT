# Keil uVision project tmpl_userapp.uvprojx, settings and files
target A34G43x (6240000::V6.24::ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: tmpl_userapp
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: EXTRN_SUBFAMILY_A34G43x EXTRN_ABOV_MODULE_CONFIG
  c include: ..\..\..\..\Framework\CMSIS\Core\Include;..\..\..\..\Framework\CMSIS\Device\ABOV\Include;..\..\..\..\ProductConfig\Config;..\..\..\..\Platform\HAL\Include;..\..\..\..\Platform\HAL\HPL\Include;..\..\..\..\Platform\Library\ABOV\Debug\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: ..\..\..\..\Framework\CMSIS\Device\ABOV\Source\ARM\ac6_a34g43x.sct
  link misc: --diag_suppress L6314W
  group Config
    ../../../../ProductConfig/Config/: abov_config.h abov_module_config.h
  group Main
    ../../../Source/TmplUserApp/: main.c prv_scu_clk.c prv_user_code.c user_adc.c user_adc_isr.c user_i2c.c user_i2c_isr.c user_timer1.c user_timer1_isr.c user_uart.c user_uart_isr.c
  group Startup
    ../../../../Framework/CMSIS/Device/ABOV/Source/: startup_a34xxxx.c
  group System
    ../../../../Framework/CMSIS/Device/ABOV/Source/: system_a34xxxx.c
  group HAL
    ../../../../Platform/HAL/ADC/: hal_adc.c
    ../../../../Platform/HAL/AES/: hal_aes.c
    ../../../../Platform/HAL/CMP/: hal_cmp.c
    ../../../../Platform/HAL/CRC/: hal_crc.c
    ../../../../Platform/HAL/FMC/: hal_fmc.c
    ../../../../Platform/HAL/FRT/: hal_frt.c
    ../../../../Platform/HAL/HPL/DMA/: hpl_dma.c
    ../../../../Platform/HAL/HPL/NMI/: hpl_nmi.c
    ../../../../Platform/HAL/I2C/: hal_i2c.c
    ../../../../Platform/HAL/MPWM/: hal_mpwm.c
    ../../../../Platform/HAL/PCU/: hal_pcu.c
    ../../../../Platform/HAL/PGA/: hal_pga.c
    ../../../../Platform/HAL/QEI/: hal_qei.c
    ../../../../Platform/HAL/RNG/: hal_rng.c
    ../../../../Platform/HAL/SCU/: hal_scu_pwr.c hal_scu_lvd.c hal_scu_clk.c hal_scu.c
    ../../../../Platform/HAL/SPI/: hal_spi.c
    ../../../../Platform/HAL/Timer1/: hal_timer1.c
    ../../../../Platform/HAL/UART/: hal_uart.c
    ../../../../Platform/HAL/WDT/: hal_wdt.c
    ../../../../Platform/HAL/DAC/: hal_dac.c
    ../../../../Platform/HAL/RTC/: hal_rtc.c
    ../../../../Platform/HAL/LPUART/: hal_lpuart.c
    ../../../../Platform/HAL/USART/: hal_usart.c
    ../../../../Platform/HAL/LCD/: hal_lcd.c
    ../../../../Platform/HAL/VREFBUF/: hal_vrefbuf.c
    ../../../../Platform/HAL/PWM/: hal_pwm.c
    ../../../../Platform/HAL/QSPI/: hal_qspi.c
  group Debug
    ../../../../Platform/Library/ABOV/Debug/Source/: debug.c debug_cmd.c debug_hardfault.c debug_log.c debug_retarget.c debug_serial.c
  group DebugLibrary
    ../../../Source/TmplUserApp/DebugLibrary/: debug_framework.c
  group Sht40
    ../../../Source/TmplUserApp/Sht40/: SHT40_app.c sht4x_i2c.c sensirion_i2c_hal.c sensirion_common.c sensirion_i2c.c
  group MP23ABS1
    ../../../Source/TmplUserApp/MP23ABS1/: mp23abs1_sensor.c
  group BatteryReading
    ../../../Source/TmplUserApp/BatteryReading/: battery_reading.c
  group LISDE12TR
    ../../../Source/TmplUserApp/LISDE12TR/: lis2de12.c LIS2DE12_app.c
  group ESP32_AT_TEST
    ../../../Source/TmplUserApp/ESP32_AT_Test/: ESP32_AT_Test.c
  group MQTT_Library
    ../../../Source/TmplUserApp/MQTT_Library/: mqtt_port_abov.c mqtt_core.c EMPA_MqttAws.c
  group Sensor
    ../../../Source/TmplUserApp/Sensor/: sensor.c
